Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-10T12:15:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 10 12:15:19 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\8f93c90a-c7b8-4513-8acb-ad717d5238bc\5fcd4f9c-5b00-40eb-9d28-627eb7763bca\ifc * Database version: 5507 * Database creation date: Thu Oct 10 12:15:18 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 10 12:15:19 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 10 12:15:19 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 89859083 Cover part for shower faucet, 89859083:89859083 Cover part for shower faucet:508124
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - NominalDepth: 82.4381 mm; NominalHeight: 184.987 mm; NominalWidth: 150 mm
Type - General - Author: BIMStone; BIMObjectName: 89859083; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - Approval ABP: PA-IX 38160/IB; Approval DVGW: DW-6506CS0196; EAN Number: 4015474285552; EN Standard: EN 817; ETIM Class Number: EC010546 Mechanical control system for shower; Noise Class: I (ISO 3822); Sales Package dimensions (LxWxH): 204 x 186 x 174; UNSPSC Class Number: 30181810 Faucet trim; URL ABP: http://static.hansa.com/ABP/89859083; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/89859083; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL DVGW: http://static.hansa.com/DVGW/89859083; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://static.hansa.com/EPD/89859083; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/169386_89859083_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - Catalog Drawing URL: http://static.hansa.com/catdrw/89859083; Category B2C: Shower solutions; Color variants: 8985908333; Dimension Drawing URL: http://static.hansa.com/dimdrw/89859083; FDV Document URL: http://www.hansa.com/datasheet/89859083/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/89859083; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/89859083; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/89859083; Model: 89859083 Cover part for shower faucet; Name_en: 89859083 Cover part for shower faucet; OmniClass Number: 23.45.55.00; Product Code: 89859083; Product Family: HANSATWIST; Product Image URL: http://static.hansa.com/image/89859083; Product URL: http://static.hansa.com/89859083; Spare-Part Information URL: http://static.hansa.com/sp/89859083; Technical DataSheet URL: http://www.hansa.com/datasheet/89859083/en; Type Name: 89859083 Cover part for shower faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Concealed Parts: Square rosette;Fastening of the function unit with screws;BLUECLICK for an easy, screwless trim plate installation; Flow Rate At 300kPa: 0.012007 m3/s; Installation Type: Concealed wall mounting; Lever Handle: Hot/Cold symbols;Single operating lever/handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: ø 35 mm ceramic cartridge for flow and temperature control; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 89859083; Features: Single-lever;Trim Kit; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 89859083; Name: 89859083 Cover part for shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 150x82x185 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 89859083 Cover part for shower faucet; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 89859083; Manufacturer: HANSA
Pset_ProductRequirements - Name: 89859083 Cover part for shower faucet; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0553636 m2; Volume: 0.00228749 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 89859083: 89859083 Cover part for shower faucet; Family and Type: 89859083: 89859083 Cover part for shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 89859083: 89859083 Cover part for shower faucet; Type Id: 89859083: 89859083 Cover part for shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
